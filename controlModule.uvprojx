# Keil uVision project controlModule.uvprojx, settings and files
target controlModule (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC1114FDH28/102 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: controlModule
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.3.0\CMSIS\Include\
  memory RVCT4: ROM 0x0 size 0x7000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Startup
    ./: system_LPC11xx.c startup_LPC11xx.s bsp.c bsp.h
  group Serial
    ./: main.c Serial.c Retarget.c
  group database
    ./: database.c database.h
  group flash
    ./: flash.c flash.h
  group GPS
    ./: GPS.c GPS.h
  group UART
    ./: UART.c UART.h
  group LED
    ./: LED.c LED.h
  group timer
    ./: timer.c timer.h
  group SPI
    ./: SPI.c SPI.h
  group bluetooth
    ./: bluetooth.c bluetooth.h
  group stopwatch
    ./: stopwatch.c stopwatch.h
  group button
    ./: button.c button.h
software components: CMSIS:CORE 5.1.1
